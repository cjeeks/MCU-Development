# IAR project MSP430-demo.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: ADC.c bmp085.c bmp085.h body.c DCMoto.c DCMoto.h DDPLAY.c DDPLAY.h DTH11.c dth11.h enc28j60.c gas.c GPIO.c GPIO.h ip_arp_udp.c LCD.c LCD.h LED_ARRAY.c LED_ARRAY.h macro.h main.c net_main.c Relay.c Relay.h RS232.c RS232.h SteperMoto.c SteperMoto.h timeout.c tm1638.c tm1638.h TP.c TP.h
