<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MSP430-ADC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\MSP430-ADC1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


