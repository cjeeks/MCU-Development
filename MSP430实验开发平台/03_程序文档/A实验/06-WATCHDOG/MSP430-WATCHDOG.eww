<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MSP430-WATCHDOG.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\MSP430-WATCHDOG-1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


