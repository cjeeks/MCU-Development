# Keil uVision project Test.uvprojx, settings and files
target Test (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Test_2 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F4XX,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\User;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\BaseDrive;..\ExternalDrive\lcd;..\ExternalDrive\delay;..\ExternalDrive\TM1638;..\ExternalDrive\BMP085;..\ExternalDrive\DTH11;..\ExternalDrive\MMA7455;F:\Keil_v5\ARM\Pack\ARM\CMSIS\4.3.0\CMSIS\Include;..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Cmsis
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group User
    ../User/: main.c stm32f4xx_it.c
  group Lib
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group BaseDrive
    ../BaseDrive/: Gpio.c SysTick.c Uart.c
  group ExternalDrive\lcd
    ../ExternalDrive/lcd/: lcd.c
    ../ExternalDrive/TM1638/: tm1638.c
    ../ExternalDrive/delay/: delay.c
    ../ExternalDrive/BMP085/: BMP085.C
    ../ExternalDrive/DTH11/: DTH11.c
    ../ExternalDrive/MMA7455/: MMA7455.c
  group Doc
    ../Doc/: ReadMe.txt
