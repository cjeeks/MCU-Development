# Keil uVision project ceshi.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: ceshi +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./LCD/: LCD.c
    ./sys/: sys.c
    ./font/: font.c
    ./touch/: touch.c
    ./PCF8574T/: PCF8574T.c
    ./UART/: UART.c
    ./BMP085/: bmp085.c
    ./MMA7455/: MMA7455.c
    ./ENC28J60/: enc28j60_test.c enc28j60.c spi.c uip_arch.c uip_arp.c uipopt.h
    ./key/: key.c
    ./DotMatrix/: Dot_Matrix.c
    ./RELAY/: relay.c
    ./DC_MOTOR/: DC_motor.c
    ./STEP_MOTOR/: step_motor.c
    ./DHT11/: dht11.c
