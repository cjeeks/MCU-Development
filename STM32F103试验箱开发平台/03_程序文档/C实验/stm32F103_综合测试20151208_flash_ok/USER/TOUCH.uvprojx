# Keil uVision project TOUCH.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\TOUCH;..\HARDWARE\KEYPAD;..\HARDWARE\RELAY;..\HARDWARE\DHT11;..\HARDWARE\DC_MOTOR;..\HARDWARE\STEP_MOTOR;..\HARDWARE\DIP;..\HARDWARE\ACC_GAS_PRE;..\HARDWARE\MMA7455;..\HARDWARE\PCF8574;..\HARDWARE\ENC28J60
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/TOUCH/: touch.c
    ../HARDWARE/KEYPAD/: keypad.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/DC_MOTOR/: DC_motor.c
    ../HARDWARE/STEP_MOTOR/: step_motor.c
    ../HARDWARE/DIP/: Dot_Matrix.c
    ../HARDWARE/ACC_GAS_PRE/: bmp085.c
    ../HARDWARE/MMA7455/: MMA7455.c
    ../HARDWARE/PCF8574/: PCF8574.c
    ../HARDWARE/ENC28J60/: enc28j60.c SPI.C simple_server.c ip_arp_udp_tcp.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c misc.c
software components: CMSIS:CORE 4.1.0
